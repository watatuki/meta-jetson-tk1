EXTRA_OECONF += " --enable-ld-version-script "
